Commit message: right axes, and height

File: sim/resources/zeroth/robot_fixed.urdf (robot description, URDF)
Before this commit: robot zeroth, 12 links, 11 joints
Joints:
- joint floating_base: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 -1.5707963267948966
