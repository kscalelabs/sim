Commit message: functional k2

File: sim/resources/k2/robot.urdf (robot description, URDF)
Before this commit: robot kbot-v2, 23 links, 22 joints
Joints:
- joint floating_base_joint: origin xyz=0 0 0 rpy=0.00 0.00 0.00 -> xyz=0 0 0 rpy=0.00 0.00 -1.570796
